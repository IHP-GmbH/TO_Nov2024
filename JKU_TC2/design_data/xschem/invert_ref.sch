v {xschem version=3.4.6RC file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {iopin.sym} 180 -160 0 1 {name="p1" lab="clk"}
C {iopin.sym} 180 -140 0 1 {name="p2" lab="out"}
C {iopin.sym} 180 -120 0 1 {name="p3" lab="rst_n"}
