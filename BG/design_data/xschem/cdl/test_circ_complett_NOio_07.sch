v {xschem version=3.4.6RC file_version=1.2
*
* This file is part of XSCHEM,
* a schematic capture and Spice/Vhdl/Verilog netlisting tool for circuit
* simulation.
* Copyright (C) 1998-2023 Stefan Frederik Schippers
*
* This program is free software; you can redistribute it and/or modify
* it under the terms of the GNU General Public License as published by
* the Free Software Foundation; either version 2 of the License, or
* (at your option) any later version.
*
* This program is distributed in the hope that it will be useful,
* but WITHOUT ANY WARRANTY; without even the implied warranty of
* MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
* GNU General Public License for more details.
*
* You should have received a copy of the GNU General Public License
* along with this program; if not, write to the Free Software
* Foundation, Inc., 51 Franklin Street, Fifth Floor, Boston, MA 02110-1301 USA
}
G {}
K {}
V {}
S {}
E {}
N 2540 -2480 2580 -2480 {
lab=IOVDD}
N 2380 -2480 2420 -2480 {
lab=VSS}
N 2510 -2580 2510 -2550 {
lab=gates}
N 2500 -2580 2500 -2550 {
lab=gates}
N 2500 -2580 2510 -2580 {
lab=gates}
N 2240 -2500 2240 -2480 {
lab=#net1}
N 2240 -2500 2420 -2500 {
lab=#net1}
N 2640 -2720 2640 -2670 {
lab=IOVDD}
N 2320 -2720 2320 -2670 {
lab=IOVDD}
N 2960 -2720 2960 -2670 {
lab=IOVDD}
N 2320 -2040 2320 -1990 {lab=VSS}
N 2360 -2090 2380 -2090 {lab=VSS}
N 2520 -2060 2520 -1990 {lab=VSS}
N 2440 -2060 2440 -1990 {lab=VSS}
N 2320 -2200 2350 -2200 {lab=#net2}
N 2440 -2200 2450 -2200 {lab=mpa1}
N 2520 -2200 2550 -2200 {lab=mpa2}
N 2320 -2200 2320 -2120 {lab=#net2}
N 2440 -2200 2440 -2120 {lab=mpa1}
N 2410 -2200 2440 -2200 {lab=mpa1}
N 2520 -2200 2520 -2120 {lab=mpa2}
N 2510 -2200 2520 -2200 {lab=mpa2}
N 2320 -2610 2320 -2200 {lab=#net2}
N 2960 -2050 2960 -1980 {lab=VSS}
N 2640 -2610 2640 -2200 {lab=#net3}
N 2640 -2200 2640 -2170 {lab=#net3}
N 2610 -2200 2640 -2200 {lab=#net3}
N 2640 -2110 2640 -2090 {lab=mpa10}
N 2380 -2480 2380 -2420 {lab=VSS}
N 2480 -2580 2480 -2550 {
lab=gates}
N 2320 -2040 2380 -2040 {lab=VSS}
N 2320 -2060 2320 -2040 {lab=VSS}
N 2380 -2090 2380 -2040 {lab=VSS}
N 2550 -2040 2640 -2040 {lab=VSS}
N 2600 -2090 2600 -2070 {lab=mpa10}
N 2670 -2090 2680 -2090 {lab=mpa10}
N 2680 -2090 2680 -2070 {lab=mpa10}
N 2670 -2090 2670 -2070 {lab=mpa10}
N 2660 -2090 2670 -2090 {lab=mpa10}
N 2660 -2090 2660 -2070 {lab=mpa10}
N 2650 -2090 2660 -2090 {lab=mpa10}
N 2650 -2090 2650 -2070 {lab=mpa10}
N 2640 -2090 2650 -2090 {lab=mpa10}
N 2640 -2090 2640 -2070 {lab=mpa10}
N 2630 -2090 2640 -2090 {lab=mpa10}
N 2630 -2090 2630 -2070 {lab=mpa10}
N 2620 -2090 2630 -2090 {lab=mpa10}
N 2620 -2090 2620 -2070 {lab=mpa10}
N 2610 -2090 2620 -2090 {lab=mpa10}
N 2610 -2090 2610 -2070 {lab=mpa10}
N 2600 -2090 2610 -2090 {lab=mpa10}
N 2680 -2010 2680 -1990 {lab=VSS}
N 2600 -1990 2610 -1990 {lab=VSS}
N 2600 -2010 2600 -1990 {lab=VSS}
N 2610 -2010 2610 -1990 {lab=VSS}
N 2610 -1990 2620 -1990 {lab=VSS}
N 2620 -2010 2620 -1990 {lab=VSS}
N 2620 -1990 2630 -1990 {lab=VSS}
N 2630 -2010 2630 -1990 {lab=VSS}
N 2630 -1990 2640 -1990 {lab=VSS}
N 2640 -2010 2640 -1990 {lab=VSS}
N 2640 -1990 2650 -1990 {lab=VSS}
N 2650 -2010 2650 -1990 {lab=VSS}
N 2650 -1990 2660 -1990 {lab=VSS}
N 2660 -2010 2660 -1990 {lab=VSS}
N 2660 -1990 2670 -1990 {lab=VSS}
N 2670 -2010 2670 -1990 {lab=VSS}
N 2670 -1990 2680 -1990 {lab=VSS}
N 2550 -2040 2550 -1990 {lab=VSS}
N 2550 -1990 2600 -1990 {lab=VSS}
N 3120 -2720 3120 -2670 {
lab=IOVDD}
N 2480 -2580 2500 -2580 {lab=gates}
N 2480 -2640 2480 -2580 {
lab=gates}
N 2520 -2580 2520 -2550 {lab=gates}
N 2510 -2580 2520 -2580 {lab=gates}
N 2480 -2640 3080 -2640 {lab=gates}
N 2080 -2640 2080 -2480 {lab=gates}
N 2080 -2640 2480 -2640 {lab=gates}
N 2450 -2420 2450 -2350 {lab=mpa1}
N 2510 -2420 2510 -2350 {lab=mpa2}
N 2450 -2290 2450 -2200 {lab=mpa1}
N 2510 -2290 2510 -2200 {lab=mpa2}
N 2580 -2550 2580 -2480 {lab=IOVDD}
N 1580 -2480 1760 -2480 {lab=BiASesd}
N 3120 -2480 3300 -2480 {lab=REFCUResd}
N 3120 -2610 3120 -2480 {lab=REFCUResd}
N 2960 -2140 2960 -2110 {lab=REF}
N 2640 -2200 2770 -2200 {lab=#net3}
N 2830 -2200 3120 -2200 {lab=ADJesd}
N 3120 -2200 3120 -2080 {lab=ADJesd}
N 3120 -2080 3300 -2080 {lab=ADJesd}
N 3040 -1680 3040 -1550 {
lab=IOVDD}
N 2870 -1540 2900 -1540 {
lab=DRV_SHUNT}
N 2870 -1520 2900 -1520 {
lab=DRV_SHUNT}
N 2900 -1540 2900 -1520 {lab=DRV_SHUNT}
N 2710 -1490 2740 -1490 {lab=#net4}
N 2710 -1550 2740 -1550 {lab=REFesd}
N 2800 -1680 2800 -1580 {lab=IOVDD}
N 2800 -1460 2800 -1360 {lab=VSS}
N 2870 -1680 2870 -1550 {lab=IOVDD}
N 2900 -1520 3000 -1520 {
lab=DRV_SHUNT}
N 2560 -1410 2560 -1360 {lab=VSS}
N 2560 -1490 2560 -1470 {lab=#net4}
N 2560 -1490 2650 -1490 {lab=#net4}
N 2560 -1570 2560 -1490 {lab=#net4}
N 3040 -1120 3040 -990 {
lab=IOVDD}
N 2870 -980 2900 -980 {
lab=DRV_VDDL}
N 2870 -960 2900 -960 {
lab=DRV_VDDL}
N 2900 -980 2900 -960 {lab=DRV_VDDL}
N 2710 -930 2740 -930 {lab=VDD}
N 2710 -990 2740 -990 {lab=REFesd}
N 2800 -1120 2800 -1020 {lab=IOVDD}
N 2800 -900 2800 -800 {lab=VSS}
N 2870 -1120 2870 -990 {lab=IOVDD}
N 2900 -960 3000 -960 {
lab=DRV_VDDL}
N 3040 -840 3040 -750 {lab=VDD}
N 2560 -1280 2780 -1280 {lab=BiASesd}
N 2820 -900 2820 -750 {lab=#net5}
N 2640 -930 2650 -930 {lab=VDD}
N 2640 -930 2640 -840 {lab=VDD}
N 2640 -840 3040 -840 {lab=VDD}
N 3040 -880 3040 -840 {lab=VDD}
N 2480 -1550 2650 -1550 {lab=REFesd}
N 2480 -1520 2480 -990 {lab=REFesd}
N 2480 -990 2650 -990 {lab=REFesd}
N 2820 -1460 2820 -1310 {lab=#net6}
N 2560 -1680 2560 -1630 {lab=IOVDD}
N 3040 -1490 3040 -1370 {lab=SHUNT_GND}
N 3120 -1120 3120 -880 {lab=VDD}
N 3040 -880 3120 -880 {lab=VDD}
N 3040 -930 3040 -880 {lab=VDD}
N 3520 -1520 3520 -1500 {lab=SHUNT_GND}
N 3440 -1520 3520 -1520 {lab=SHUNT_GND}
N 2560 -720 3000 -720 {lab=BiASesd}
N 2480 -1550 2480 -1520 {lab=REFesd}
N 2140 -1520 2480 -1520 {lab=REFesd}
N 2870 -400 3120 -400 {
lab=OTA_OUT}
N 2710 -370 2740 -370 {lab=#net7}
N 2710 -430 2740 -430 {lab=OTAesd+}
N 2800 -560 2800 -460 {lab=IOVDD}
N 2800 -340 2800 -240 {lab=VSS}
N 2870 -560 2870 -420 {lab=IOVDD}
N 2820 -340 2820 -190 {lab=#net8}
N 2560 -720 2560 -160 {lab=BiASesd}
N 2560 -1280 2560 -720 {lab=BiASesd}
N 3520 -400 3520 -380 {lab=OTA_OUT}
N 3440 -400 3520 -400 {lab=OTA_OUT}
N 2140 -280 2480 -280 {lab=#net7}
N 2480 -370 2480 -280 {lab=#net7}
N 2480 -370 2650 -370 {lab=#net7}
N 2140 -520 2480 -520 {lab=OTAesd+}
N 2480 -520 2480 -430 {lab=OTAesd+}
N 2480 -430 2650 -430 {lab=OTAesd+}
N 1820 -210 1820 -160 {lab=BiASesd}
N 1800 -160 1820 -160 {lab=BiASesd}
N 1760 -210 1820 -210 {lab=BiASesd}
N 2560 -160 2780 -160 {lab=BiASesd}
N 1820 -160 2560 -160 {lab=BiASesd}
N 1760 -210 1760 -190 {lab=BiASesd}
N 1760 -2450 2200 -2450 {lab=BiASesd}
N 1760 -2450 1760 -210 {lab=BiASesd}
N 1760 -2480 1760 -2450 {lab=BiASesd}
N 2870 -1500 2870 -1360 {lab=VSS}
N 2870 -940 2870 -800 {lab=VSS}
N 2870 -380 2870 -240 {lab=VSS}
N 3040 -1370 3440 -1370 {lab=SHUNT_GND}
N 3440 -1520 3440 -1370 {lab=SHUNT_GND}
N 2160 -1280 2160 -1200 {lab=IOVSS}
N 2160 -1280 2210 -1280 {lab=IOVSS}
N 2270 -1280 2320 -1280 {lab=VSS}
N 2320 -1280 2320 -1200 {lab=VSS}
N 1920 -1410 1920 -1380 {lab=VSS}
N 1920 -1520 1920 -1470 {lab=REF}
N 1990 -1520 2020 -1520 {lab=REF}
N 1990 -1800 1990 -1520 {lab=REF}
N 1920 -1520 1990 -1520 {lab=REF}
N 1990 -1800 3040 -1800 {lab=REF}
N 3040 -2140 3040 -1800 {lab=REF}
N 2960 -2140 3040 -2140 {lab=REF}
N 2960 -2610 2960 -2140 {lab=REF}
N 3120 -400 3120 -280 {lab=OTA_OUT}
N 3120 -280 3440 -280 {lab=OTA_OUT}
N 3440 -400 3440 -280 {lab=OTA_OUT}
C {tcleval(tcleval([xschem get current_dirname]/OTA3C.sym))} 2480 -2480 1 1 {name=x1 

nw="tcleval([string map \{\{$\} \{\}\} [ev7 \{$nw\}]])" 
nl="tcleval([string map \{\{$\} \{\}\} [ev7 \{$nl\}]])" 
pw="tcleval([string map \{\{$\} \{\}\} [ev7 \{$pw\}]])" 
pl="tcleval([string map \{\{$\} \{\}\} [ev7 \{$pl\}]])" 



}
C {pwroli.sym} 2240 -2420 0 1 {name=l5 lab=VSS}
C {pwroli.sym} 2640 -2720 2 1 {name=l8 lab=IOVDD
}
C {pmolis-sub2.sym} 2620 -2640 0 0 {name=M11 model=sg13_hv_pmos  w="tcleval([string map \{\{$\} \{\}\} [ev \{$pw\}]])" l="tcleval([string map \{\{$\} \{\}\} [ev \{$pl\}]])" 
substrate=VDD
ng=1 m=1}
C {pwroli.sym} 2320 -2720 2 1 {name=l11 lab=IOVDD
}
C {pmolis-sub2.sym} 2340 -2640 0 1 {name=M14 model=sg13_hv_pmos  w="tcleval([string map \{\{$\} \{\}\} [ev \{$pw\}]])" l="tcleval([string map \{\{$\} \{\}\} [ev \{$pl\}]])" 
substrate=VDD
ng=1 m=1}
C {pwroli.sym} 2960 -2720 2 1 {name=l7 lab=IOVDD
}
C {pmolis-sub2.sym} 2940 -2640 0 0 {name=M2 model=sg13_hv_pmos  w="tcleval([string map \{\{$\} \{\}\} [ev \{$pw\}]])" l="tcleval([string map \{\{$\} \{\}\} [ev \{$pl\}]])" 
substrate=VDD
ng=1 m=1}
C {sg13g2_pr/pnpMPA.sym} 2340 -2090 0 1 {name=Q1
model=pnpMPA
spiceprefix=X
w=1.0u
l=2.0u
}
C {ammeter.sym} 2320 -1960 0 1 {name=Vmeas7 savecurrent=true
lvs_ignore=short}
C {ammeter.sym} 2520 -1960 0 0 {name=Vmeas10 savecurrent=true
lvs_ignore=short}
C {ammeter.sym} 2440 -1960 0 0 {name=Vmeas11 savecurrent=true
lvs_ignore=short}
C {ammeter.sym} 2960 -1950 0 0 {name=Vmeas12 savecurrent=true
lvs_ignore=short}
C {sg13g2_pr/pnpMPA.sym} 2660 -2040 0 0 {name=Q12
model=pnpMPA
spiceprefix=X
w=1.0u
l=2.0u
m=9}
C {ammeter.sym} 2640 -1960 0 0 {name=Vmeas9 savecurrent=true
lvs_ignore=short}
C {pwroli.sym} 2320 -1930 0 0 {name=l6 lab=VSS}
C {pwroli.sym} 2440 -1930 0 0 {name=l10 lab=VSS}
C {pwroli.sym} 2520 -1930 0 0 {name=l12 lab=VSS}
C {pwroli.sym} 2640 -1930 0 0 {name=l13 lab=VSS}
C {pwroli.sym} 2960 -1920 0 0 {name=l15 lab=VSS}
C {pwroli.sym} 2380 -2420 0 1 {name=l16 lab=VSS}
C {pwroli.sym} 2580 -2550 2 1 {name=l3 lab=IOVDD
}
C {ngspice_probe.sym} 2480 -2640 3 0 {name=r7}
C {lab_pin.sym} 2440 -2150 0 0 {name=p2 sig_type=std_logic lab=mpa1
}
C {lab_pin.sym} 2640 -2110 0 1 {name=p3 sig_type=std_logic lab=mpa10}
C {lab_pin.sym} 2480 -2610 0 1 {name=p4 sig_type=std_logic lab=gates}
C {ngspice_probe.sym} 2320 -2200 3 0 {name=r8}
C {ngspice_probe.sym} 2640 -2200 3 0 {name=r14}
C {sg13g2_pr/pnpMPA.sym} 2580 -2040 0 0 {name=Q3
model=pnpMPA
spiceprefix=X
w=1.0u
l=2.0u
m=9}
C {sg13g2_pr/pnpMPA.sym} 2590 -2040 0 0 {name=Q5
model=pnpMPA
spiceprefix=X
w=1.0u
l=2.0u
m=9}
C {sg13g2_pr/pnpMPA.sym} 2600 -2040 0 0 {name=Q6
model=pnpMPA
spiceprefix=X
w=1.0u
l=2.0u
m=9}
C {sg13g2_pr/pnpMPA.sym} 2610 -2040 0 0 {name=Q7
model=pnpMPA
spiceprefix=X
w=1.0u
l=2.0u
m=9}
C {sg13g2_pr/pnpMPA.sym} 2620 -2040 0 0 {name=Q8
model=pnpMPA
spiceprefix=X
w=1.0u
l=2.0u
m=9}
C {sg13g2_pr/pnpMPA.sym} 2630 -2040 0 0 {name=Q9
model=pnpMPA
spiceprefix=X
w=1.0u
l=2.0u
m=9}
C {sg13g2_pr/pnpMPA.sym} 2640 -2040 0 0 {name=Q10
model=pnpMPA
spiceprefix=X
w=1.0u
l=2.0u
m=9}
C {sg13g2_pr/pnpMPA.sym} 2650 -2040 0 0 {name=Q11
model=pnpMPA
spiceprefix=X
w=1.0u
l=2.0u
m=9}
C {lab_pin.sym} 2520 -2170 0 0 {name=p5 sig_type=std_logic lab=mpa2
}
C {pwroli.sym} 3120 -2720 2 1 {name=l20 lab=IOVDD
}
C {pmolis-sub2.sym} 3100 -2640 0 0 {name=M4 model=sg13_hv_pmos  w="tcleval([string map \{\{$\} \{\}\} [ev \{$pw\}]])" l="tcleval([string map \{\{$\} \{\}\} [ev \{$pl\}]])" 
substrate=VDD
ng=1 m=1}
C {pwroli.sym} 2460 -2550 2 1 {name=l22 lab=IOVDD
}
C {pwroli.sym} 2080 -2420 0 1 {name=l2 lab=VSS}
C {vsource.sym} 2510 -2320 0 0 {name=Vzero1 value=\{offset/2\}  net_name=true
lvs_ignore=short}
C {vsource.sym} 2450 -2320 2 0 {name=Vzero2 value=\{offset/2\}  net_name=true
lvs_ignore=short}
C {nmolis-sub2.sym} 2060 -2450 0 0 {name=M1


ng=1
m=1
substrate=VSS
model=sg13_hv_nmos
spiceprefix=X
w="tcleval([string map \{\{$\} \{\}\} [ev \{$nw\}]])"
l="tcleval([string map \{\{$\} \{\}\} [ev \{10 * $nl\}]])"}
C {nmolis-sub2.sym} 2220 -2450 0 0 {name=M3


ng=1
m=1
substrate=VSS
model=sg13_hv_nmos
spiceprefix=X
w="tcleval([string map \{\{$\} \{\}\} [ev \{$nw\}]])"
l="tcleval([string map \{\{$\} \{\}\} [ev \{$nl\}]])"}
C {launcher.sym} 2400 -1600 0 0 {
descr="xyce netlist simulate corners ALL" 

tclcommand="

    proc simulate_and_plot \{corners load_the_plots\} \{

	global netlist_dir
	global execute
	global mos_corner
	global sim_command
	global simulations

        set schematic [file rootname [file tail [xschem get schname 0]]]

        foreach corner $corners \{ 
            set mos_corner $\{corner\};
            foreach sim $simulations \{ 
                set sim_command $sim;

                xschem netlist $\{netlist_dir\}/$\{schematic\}_$\{sim\}_mos$\{corner\}.spice
            \}
        \}

        puts netlists_written;

        foreach corner $corners \{ 
            foreach sim $simulations \{
                xschem set netlist_name $\{schematic\}_$\{sim\}_mos$\{corner\}.spice
                set id_$\{sim\}_$\{corner\} [simulate ]
            \}
        \}

        puts sims_started;

        while \{[llength [get_running_cmds]]\} \{

            puts -nonewline .; flush stdout;

            delay 99;
        \}

        if \{$\{load_the_plots\}\} \{
            xschem raw_clear;
            xschem annotate_op $\{netlist_dir\}/$\{schematic\}_ac_mostt.raw
        \}

        puts done

    \}


    xschem set netlist_type spice
    set lvs_ignore 0
    set lvs_netlist 0
    set spiceprefix 1

    simulate_and_plot $\{corners\} true
"}
C {rppd.sym} 2640 -2140 0 0 {name=R1
w=1e-6
l=45e-6
model=rppd
spiceprefix=X
b=0
m=1
}
C {rppd.sym} 2440 -2090 2 0 {name=R2
w=1e-6
l=300e-6
model=rppd
spiceprefix=X
b=0
m=1
}
C {rppd.sym} 2580 -2200 1 0 {name=R3
w=1e-6
l=6e-6
model=rppd
spiceprefix=X
b=0
m=1
}
C {rppd.sym} 2380 -2200 3 0 {name=R4
w=1e-6
l=6e-6
model=rppd
spiceprefix=X
b=0
m=1
}
C {rppd.sym} 2520 -2090 2 0 {name=R5
w=1e-6
l=300e-6
model=rppd
spiceprefix=X
b=0
m=1
}
C {rppd.sym} 2960 -2080 2 0 {name=R6
w=1e-6
l=400e-6
model=rppd
spiceprefix=X
b=0
m=1
}
C {rppd.sym} 2800 -2200 1 0 {name=R9
w=1e-6
l=6e-6
model=rppd
spiceprefix=X
b=0
m=1
}
C {pwroli.sym} 3040 -1680 2 1 {name=l14 lab=IOVDD
}
C {pmolis-sub2.sym} 3020 -1520 0 0 {name=M6 model=sg13_hv_pmos  w="tcleval([string map \{\{$\} \{\}\} [ev \{300e-6\}]])" l="tcleval([string map \{\{$\} \{\}\} [ev \{$pl\}]])" 
substrate=VDD
ng=20 m=1}
C {tcleval(tcleval([xschem get current_dirname]/OTA3C.sym))} 2800 -1520 0 0 {name=x12 

nw="tcleval([string map \{\{$\} \{\}\} [ev7 \{$nw\}]])" 
nl="tcleval([string map \{\{$\} \{\}\} [ev7 \{$nl\}]])" 
pw="tcleval([string map \{\{$\} \{\}\} [ev7 \{$pw\}]])" 
pl="tcleval([string map \{\{$\} \{\}\} [ev7 \{$pl\}]])" 



}
C {pwroli.sym} 2800 -1360 0 0 {name=l64 lab=VSS}
C {pwroli.sym} 2800 -1680 2 0 {name=l65 lab=IOVDD
}
C {vsource.sym} 2680 -1550 1 1 {name=Vzero3 value=\{offset/2\}  net_name=true
lvs_ignore=short}
C {vsource.sym} 2680 -1490 3 1 {name=Vzero4 value=\{offset/2\}  net_name=true
lvs_ignore=short}
C {pwroli.sym} 2870 -1680 2 0 {name=l66 lab=IOVDD
}
C {rppd.sym} 2560 -1600 2 0 {name=R10
w=1e-6
l=22e-6
model=rppd
spiceprefix=X
b=4
m=1
}
C {rppd.sym} 2560 -1440 2 0 {name=R11
w=1e-6
l=22e-6
model=rppd
spiceprefix=X
b=4
m=1
}
C {pwroli.sym} 2560 -1360 0 0 {name=l67 lab=VSS}
C {pwroli.sym} 2560 -1680 2 0 {name=l68 lab=IOVDD
}
C {pwroli.sym} 3040 -1120 2 1 {name=l69 lab=IOVDD
}
C {tcleval(tcleval([xschem get current_dirname]/OTA3C.sym))} 2800 -960 0 0 {name=x13 

nw="tcleval([string map \{\{$\} \{\}\} [ev7 \{$nw\}]])" 
nl="tcleval([string map \{\{$\} \{\}\} [ev7 \{$nl\}]])" 
pw="tcleval([string map \{\{$\} \{\}\} [ev7 \{$pw\}]])" 
pl="tcleval([string map \{\{$\} \{\}\} [ev7 \{$pl\}]])" 



}
C {pwroli.sym} 2800 -800 0 0 {name=l70 lab=VSS}
C {pwroli.sym} 2800 -1120 2 0 {name=l71 lab=IOVDD
}
C {vsource.sym} 2680 -990 1 1 {name=Vzero5 value=\{offset/2\}  net_name=true
lvs_ignore=short}
C {vsource.sym} 2680 -930 3 1 {name=Vzero6 value=\{offset/2\}  net_name=true
lvs_ignore=short}
C {pwroli.sym} 2870 -1120 2 0 {name=l72 lab=IOVDD
}
C {nmolis-sub2.sym} 3020 -960 0 0 {name=M8


ng=10
m=1
substrate=VSS
model=sg13_hv_nmos
spiceprefix=X
w="tcleval([string map \{\{$\} \{\}\} [ev \{200e-6\}]])"
l="tcleval([string map \{\{$\} \{\}\} [ev \{$nl\}]])"}
C {pwroli.sym} 2820 -690 0 0 {name=l73 lab=VSS}
C {nmolis-sub2.sym} 2800 -720 0 0 {name=M9


ng=1
m=1
substrate=VSS
model=sg13_hv_nmos
spiceprefix=X
w="tcleval([string map \{\{$\} \{\}\} [ev \{$nw\}]])"
l="tcleval([string map \{\{$\} \{\}\} [ev \{$nl\}]])"}
C {pwroli.sym} 3040 -690 0 0 {name=l74 lab=VSS}
C {nmolis-sub2.sym} 3020 -720 0 0 {name=M10


ng=1
m=1
substrate=VSS
model=sg13_hv_nmos
spiceprefix=X
w="tcleval([string map \{\{$\} \{\}\} [ev \{$nw\}]])"
l="tcleval([string map \{\{$\} \{\}\} [ev \{$nl\}]])"}
C {pwroli.sym} 2820 -1250 0 0 {name=l75 lab=VSS}
C {nmolis-sub2.sym} 2800 -1280 0 0 {name=M12


ng=1
m=1
substrate=VSS
model=sg13_hv_nmos
spiceprefix=X
w="tcleval([string map \{\{$\} \{\}\} [ev \{$nw\}]])"
l="tcleval([string map \{\{$\} \{\}\} [ev \{$nl\}]])"}
C {pwroli.sym} 3120 -1120 2 0 {name=l76 lab=VDD

}
C {ammeter.sym} 3520 -1470 0 0 {name=Vmeas1 savecurrent=true
lvs_ignore=open}
C {pwroli.sym} 3520 -1440 0 1 {name=l77 lab=VSS}
C {vsource.sym} 1920 -1350 0 0 {name=VDD1 value="1.65"  net_name=true
lvs_ignore=short}
C {pwroli.sym} 1920 -1320 0 0 {name=l82 lab=VSS}
C {res.sym} 1920 -1440 2 0 {name=R12
value=103k
footprint=1206
device=resistor
m=1
lvs_ignore=open}
C {lab_pin.sym} 2960 -1520 1 1 {name=p9 sig_type=std_logic lab=DRV_SHUNT
}
C {lab_pin.sym} 2960 -960 3 1 {name=p10 sig_type=std_logic lab=DRV_VDDL

}
C {tcleval(tcleval([xschem get current_dirname]/OTA3C.sym))} 2800 -400 0 0 {name=x10 

nw="tcleval([string map \{\{$\} \{\}\} [ev7 \{$nw\}]])" 
nl="tcleval([string map \{\{$\} \{\}\} [ev7 \{$nl\}]])" 
pw="tcleval([string map \{\{$\} \{\}\} [ev7 \{$pw\}]])" 
pl="tcleval([string map \{\{$\} \{\}\} [ev7 \{$pl\}]])" 



}
C {pwroli.sym} 2800 -240 0 0 {name=l55 lab=VSS}
C {pwroli.sym} 2800 -560 2 0 {name=l56 lab=IOVDD
}
C {vsource.sym} 2680 -430 1 1 {name=Vzero7 value=\{offset/2\}  net_name=true
lvs_ignore=short}
C {vsource.sym} 2680 -370 3 1 {name=Vzero8 value=\{offset/2\}  net_name=true
lvs_ignore=short}
C {pwroli.sym} 2870 -560 2 0 {name=l57 lab=IOVDD
}
C {pwroli.sym} 2820 -130 0 0 {name=l58 lab=VSS}
C {nmolis-sub2.sym} 2800 -160 0 0 {name=M13


ng=1
m=1
substrate=VSS
model=sg13_hv_nmos
spiceprefix=X
w="tcleval([string map \{\{$\} \{\}\} [ev \{$nw\}]])"
l="tcleval([string map \{\{$\} \{\}\} [ev \{$nl\}]])"}
C {ammeter.sym} 3520 -350 0 0 {name=Vmeas2 savecurrent=true
lvs_ignore=open
}
C {pwroli.sym} 3520 -320 0 1 {name=l85 lab=VSS}
C {pwroli.sym} 1760 -130 0 0 {name=l4 lab=VSS}
C {nmolis-sub2.sym} 1780 -160 0 1 {name=M5


ng=1
m=1
substrate=VSS
model=sg13_hv_nmos
spiceprefix=X
w="tcleval([string map \{\{$\} \{\}\} [ev \{$nw\}]])"
l="tcleval([string map \{\{$\} \{\}\} [ev \{$nl\}]])"}
C {pwroli.sym} 2870 -1360 0 0 {name=l94 lab=VSS}
C {pwroli.sym} 2870 -800 0 0 {name=l95 lab=VSS}
C {pwroli.sym} 2870 -240 0 0 {name=l96 lab=VSS}
C {sg13g2_pr/rsil.sym} 2240 -1280 3 0 {name=R15
w=10e-6
l=27e-6
model=rsil
spiceprefix=X
b=0
m=1
}
C {pwroli.sym} 2320 -1200 0 0 {name=l110 lab=VSS}
C {pwroli.sym} 2160 -1200 0 1 {name=l111 lab=IOVSS}
C {lab_pin.sym} 3520 -1520 0 1 {name=p12 sig_type=std_logic lab=SHUNT_GND
}
C {lab_pin.sym} 1920 -1520 0 0 {name=p13 sig_type=std_logic lab=REF

}
C {lab_pin.sym} 3520 -400 0 1 {name=p1 sig_type=std_logic lab=OTA_OUT

}
C {lab_pin.sym} 1760 -2410 0 0 {name=p8 sig_type=std_logic lab=BiASesd


}
C {lab_pin.sym} 3120 -2540 0 1 {name=p11 sig_type=std_logic lab=REFCUResd
}
C {lab_pin.sym} 3120 -2170 0 1 {name=p17 sig_type=std_logic lab=ADJesd
}
C {lab_pin.sym} 2480 -470 0 0 {name=p18 sig_type=std_logic lab=OTAesd+}
C {lab_pin.sym} 2470 -330 0 0 {name=p19 sig_type=std_logic lab=OTAesd-}
C {lab_pin.sym} 2480 -1550 0 0 {name=p15 sig_type=std_logic lab=REFesd

}
