v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {iopin.sym} 240 -400 0 1 {name=p8 lab=plus

}
C {iopin.sym} 300 -400 2 1 {name=p1 lab=minus

}
C {short.sym} 270 -400 1 0 {name=x1 value=0.1}
